# Keil uVision project ReFlasher.uvprojx, settings and files
target RAZ (6210000::V6.21::ARMCLANG)
  device: N32G031K8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.4
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ReFlasher
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32G031, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\inc;..\src;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\CMSIS\device\startup;..\firmware\n32g031_std_periph_driver\inc;..\firmware\n32g031_std_periph_driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g031.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g031.c
  group FWLIB
    ../firmware/n32g031_std_periph_driver/src/: n32g031_gpio.c n32g031_spi.c n32g031_rcc.c
  group USER
    ../src/: main.c n32g031_it.c spi_flash.c
